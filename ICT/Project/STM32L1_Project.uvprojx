# Keil uVision project STM32L1_Project.uvprojx, settings and files
target STM32L151 (ARM-ADS)
  device: STM32L151RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SCT_V1.0.0 +hex
  c flags: Optim=1
  c include: ..\Driver;..\main;..\STM32L1xx_StdPeriph_Driver\inc;..\STM32L1xx_StdPeriph_Driver\src;..\Driver\adc;..\Driver\system\delay;..\Driver\system\sys;..\System;..\Driver\usart;..\Driver\NRF24L01;..\Driver\STMFLASH;..\Driver\rtc;..\Driver\adc;..\Driver\spi;..\Driver\lpm;..\Driver\DS18B20;..\Driver\nbiot;..\Driver\timer;..\Driver\sht10;..\Driver\temp;..\Driver\exti;..\Driver\protocol;..\Driver\key;..\Driver\oled;..\Driver\menu;..\Driver\switch;..\Driver\show
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ./: startup_stm32l1xx_md.s
  group stm32l_lib
    ../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group main
    ../main/: main.c system_stm32l1xx.c stm32l1xx_it.c
  group sys
    ../Driver/system/delay/: delay.c
    ../Driver/system/sys/: sys.c
  group bsp
    ../Driver/usart/: usart.c
    ../Driver/NRF24L01/: 24l01.c
    ../Driver/STMFLASH/: stmflash.c
    ../Driver/rtc/: rtc.c
    ../Driver/adc/: adc.c
    ../Driver/spi/: spi.c
    ../Driver/lpm/: lpm.c
    ../Driver/DS18B20/: ds18b20.c
    ../Driver/timer/: timer.c
    ../Driver/sht10/: sht10.c
    ../Driver/temp/: temp.c
    ../Driver/nbiot/: nb_at.c nb_interface.c nb_process.c
    ../Driver/exti/: exti.c
    ../Driver/protocol/: protocol.c
    ../Driver/key/: key.c
    ../Driver/oled/: oled.c
    ../Driver/menu/: menu.c
    ../Driver/switch/: switch.c
    ../Driver/show/: show.c
